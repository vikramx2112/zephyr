## tests/drivers/random/randomnumgen_basic_api/testcase.yaml
```yaml
tests:
-   test_random_num_genrator:
        filter: CONFIG_RANDOM_HAS_DRIVER
        tags: driver
```
